Commit message: bug_fixed

File: src/realtime_demo/urdf/lexus.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link vido_camera_link: geometry visual mesh filename=/home/alwen/slam_source_code/VIDO-SLAM/src/realtime_demo/me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 scale=1.0 1.0 1.0
